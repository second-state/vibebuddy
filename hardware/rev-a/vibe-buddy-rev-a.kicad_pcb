# Repository second-state/vibebuddy

File README.md (part):

# VibeBuddy

English | [简体中文](README.zh-CN.md)

VibeBuddy is a desk pet for your AI coding agents. It lives in a small ESP32-S3 box next to your keyboard and keeps an eye on Codex, Claude Code, OpenCode, GitHub Copilot CLI, Pi and your GitHub Actions runs, so you don't have to. When an agent needs you, finishes, or fails, the buddy tells you with an animation, a task card and a short spoken line.

The buddy is an original character. Codex was the first agent it supported, but the device protocol isn't tied to any one client: any local program or script can send it events.

(The project used to be called VibeBuddy; the repository, the `vibebuddyd` daemon and the VibeBuddy Protocol keep that name.)

**Rather not build one?** A ready-to-use VibeBuddy, assembled, flashed and tested, is in stock at [vibekeys.dev](https://vibekeys.dev/vibebuddy.html?utm_source=github&utm_medium=readme&utm_campaign=vibe-buddy-launch). Everything it runs is the open-source code in this repository.

## On the box

Screen captures from a real box running the Rust firmware. Status scenes use example task names and daily stats; Pomodoro scenes show the live timer.

| Working | Input required |
| --- | --- |
|  |  |
| **Done** | **Failed** |
|  |  |
| **Ready** | **Multiple agents** |
|  |  |
| **Pomodoro focus** | **Pomodoro paused** |
|  |  |

## What it does

- **Watches your agents.** Codex, Claude Code and GitHub Actions all feed the same stack of up to three task cards, newest on top. Each card shows which agent it is (`CX:` Codex, `CC:` Claude Code, `OC:` OpenCode, `CP:` GitHub Copilot CLI, `PI:` Pi, `CI:` GitHub Actions), the session's name and the project, and how long it has been in its current state.
- **Speaks up only when it matters.** The buddy shows idle, working, needs input, done, failed and disconnected. It says one short line when an agent needs your input, finishes or fails, and stays quiet while agents work.
- **Keeps today's stats.** When nothing is going on it cycles through what got done today and now and then does a little something.

It has three modes:

- **On duty** (the default): watches your agents and calls you when something happens. Each running task gets a card with its agent's icon, three to a page; with more, the pages turn by themselves.
- **Pomodoro**: a focus timer, 25 minutes of focus and 5 of break. K0 starts, pauses and resumes, and a long press gives up; K1 switches between On duty and Pomodoro, and a long press opens the box's menu (volume, mute, status); K2 still takes you to the agent's window, and a long press mutes. Each phase ends with a chime and a spoken line, and the next one waits for you to press K0. Today's finished sessions and focus time are kept on the box, reset daily, and survive a restart.
- **Leisure**: after On duty has been idle long enough, the buddy goes off to play. After five minutes it starts little skits (patrolling, kicking a ball, reading, counting stars, hide-and-seek, startling itself awake, talking in its sleep); after half an hour it gets sleepy and dims; at night, after 90 minutes of sleep, it turns the backlight off. Any agent activity or button press brings it straight back on duty.

Some boxes have a touchscreen. On one, tap a task card to go to that agent's window (K2 goes to the most pressing one), swipe up or down to see more cards, tap a row of the box's menu to pick it, tap a key hint at the bottom of the menu to press that key or outside the menu to close it, and tap the buddy to pet it. Everything else stays on the keys, which work the same on every box.

Pomodoro runs entirely on the box: its timer and today's tally keep going without the Mac. Leisure's state also lives in the firmware, but it needs a live link to the daemon: if the box hears nothing from the Mac for 15 seconds it counts the link as lost, and Leisure returns to On duty until the link is back. Design notes: [`docs/pomodoro.md`](docs/pomodoro.md) and [`docs/leisure.md`](docs/leisure.md).

**Status:** the display and voice have passed on-device acceptance, and Codex, Claude Code and GitHub Actions are all connected. See [`docs/roadmap.md`](docs/roadmap.md) for what's next.

## What you need

- **The box:** a VibeBuddy (ESP32-S3, 16 MB flash, 8 MB PSRAM), with LCD, speaker and three buttons. One USB-C cable powers it, flashes it and carries events. [Order one](https://vibekeys.dev/vibebuddy.html?utm_source=github&utm_medium=readme&utm_campaign=vibe-buddy-launch) that ships assembled and flashed, or see [`docs/hardware.md`](docs/hardware.md) to build your own.
- **A Mac** with Apple silicon and macOS 14 or later, or a Linux or Windows machine (experimental, see below).
- **At least one agent:** Codex or Claude Code. GitHub Actions support uses the `gh` CLI you're already signed in to.

## Getting started

1. Install with Homebrew: `brew install --cask second-state/tap/vibebuddy`. Or download `VibeBuddy-<version>-arm64.dmg` from the [latest release](https://github.com/second-state/vibebuddy/releases/latest) and drag VibeBuddy to Applications. Either way the app then updates itself.
2. Plug the box into the Mac.
3. Open VibeBuddy. First-run setup walks you through:
   - finding the box (it blinks so you know it's the right one), and updating its firmware if a newer one is out;
   - connecting your agents: Codex, Claude Code, OpenCode, GitHub Copilot CLI and Pi (you see the exact change to their hook config before it's written);
   - picking a character and writing it to the box (the default robot comes first);
   - putting the box on Wi-Fi, so this Mac reaches it without the cable;
   - launching at login.

After that VibeBuddy lives in the menu bar as Kore; open the app again any time to bring up Settings. Click Kore for a panel that tells you whether the box is online, which mode it's in and how much got done today. Settings has a sidebar with six pages: Character (who the buddy is, and the volume), Agents, Conversation (voice commands), Device (firmware updates, screenshots), General (including the interface language) and Advanced. Firmware is released on its own: when a newer one the app can run is out, VibeBuddy downloads it and Settings → Device offers to update the box, which you confirm.

If a release isn't signed yet, macOS blocks the first launch; allow it under System Settings → Privacy & Security.

### Linux (experimental)

For x86_64 Linux with systemd; tested on Omarchy (Arch, Hyprland). Download `VibeBuddy-<version>-linux-x86_64.tar.gz` from the [latest release](https://github.com/second-state/vibebuddy/releases/latest), then:

```bash
tar xf VibeBuddy-<version>-linux-x86_64.tar.gz
cd VibeBuddy-<version>-linux-x86_64 && ./install.sh
```

On Arch and Omarchy you can install the same release as a pacman package instead. It goes in system-wide, and a udev rule gives you access to the box without joining a group:

```bash
git clone https://github.com/second-state/vibebuddy
cd vibebuddy/packaging/aur/vibebuddy-bin && makepkg -si
systemctl --user enable --now vibebuddyd && vibebuddy-hook install
```

It will be on the AUR as `vibebuddy-bin` once AUR registration reopens. To build from source instead, run `packaging/linux/install.sh` in a checkout with a Rust toolchain; it builds everything. Either way, the script installs the binaries into `~/.local/bin`, runs `vibebuddyd` as a systemd user service, puts the VibeBuddy app in the launcher and at login, and adds the hooks to Claude Code and Codex, whichever this machine has (Codex then wants you to trust them in `/hooks`). Run it again to upgrade. The daemon needs to be in the group that owns `/dev/ttyACM*` (`uucp` on Arch, `dialout` on Debian and Ubuntu); the script tells you if it isn't. Config lives in `~/.config/vibebuddy`, stats in `~/.local/state/vibebuddy`, and when the box is gone for 30 seconds you get a desktop notification through `notify-send`.

On Hyprland, K2 brings back the terminal window the session runs in, on whatever workspace it is; inside tmux it first switches your tmux client to the session's pane. A session over SSH has no window to go back to. The app is a tray icon (Kore; click it for settings) plus a settings window with the same pages as on the Mac, in the same korekore look. It is only a client: quitting it leaves the daemon, and the box, running. Device → Refresh shows what the box's screen shows, and Save image puts it in your Pictures folder. Character lists the Characters the script installed, plays a preview of each, and writes the one you pick to the box; Agents shows each agent's hook and connects, repairs or removes it after showing what it will write; Device offers newer firmware once the daemon has downloaded it (with a notification, once per version) and flashes a firmware zip from a file, as on the Mac. General has Launch at login. The first launch opens a short guide in the settings window: find the box (with help when it doesn't show up, and VibeBuddy firmware for a factory box), pick a character, and put the box on Wi-Fi. The script has already connected the agents and set up the start at login, so those pages are left out. Launching the app again while it runs opens the settings window. Omarchy keeps tray icons in a drawer behind the bar's chevron, so the app pins its icon to the bar the first time it runs; unpin or hide it there (right-click the chevron) and it stays that way. On Omarchy 4 the script also adds VibeBuddy's [bar plugin](https://github.com/second-state/omarchy-vibebuddy-plugin) (with the pacman package, run `omarchy plugin add https://github.com/second-state/omarchy-vibebuddy-plugin --enable` yourself): the face in the bar, with a panel for the box's status, today's stats and the volume. While the plugin is in the bar the app leaves out its tray icon, and brings it back if you disable the plugin. General → Language overrides the system language, as on the Mac. To make the settings window float on Omarchy, add `o.window("^vibebuddy$", { float = true, center = true, tag = "-default-opacity", opacity = "1.0 1.0" })` to `~/.config/hypr/hyprland.lua`: floating, centred and opaque, at the size the app asks for. Omarchy's own `floating-window` tag would pin it to 875 × 600 instead; like every Hyprland window it moves with Super + drag. To remove everything, run `vibebuddy-hook uninstall`, then `systemctl --user disable --now vibebuddyd`, then delete the files the script installed.

### Windows (experimental)

For x86_64 Windows 10 and 11. Download `VibeBuddy-<version>-windows-x86_64-setup.exe` from the [latest release](https://github.com/second-state/vibebuddy/releases/latest) and run it. The installer isn't signed yet, so SmartScreen warns first: choose More info, then Run anyway. It installs for you alone, with no admin prompt, into `%LOCALAPPDATA%\Programs\VibeBuddy`, adds VibeBuddy to the Start menu, starts it at login (a box on the installer's last page) and adds the hooks to the agents this computer has. Run a newer installer to upgrade; uninstall from Settings → Apps, which also takes the hooks out.

The app is a notification area icon (Kore; click it for settings, right-click for the menu) plus the same settings window as on Linux. Unlike on Linux, the app runs the daemon itself, as the Mac app does, so quitting it takes the box offline. Windows 10 and 11 need no driver for the box. Config lives in `%APPDATA%\VibeBuddy`, stats and the daemon's log in `%LOCALAPPDATA%\VibeBuddy`, and when the box is gone for 30 seconds you get a notification. K2 brings back the window the session runs in: the Windows Terminal window, the console, or the editor (with several Windows Terminal windows open it picks the frontmost, and it can't pick the tab). Not on Windows yet: voice commands need Developer Mode (Codex's sign-in is linked with a symlink), and Character previews don't play.

## How it works

```text
Local programs / agents / Codex / scripts
                |
                | HTTP / Unix socket
                v
             vibebuddyd
                |
                | transport abstraction
                v
          USB Serial / USB CDC
                |
                v
           ESP32-S3 box
                |
      LCD / speaker / buttons
```

- `vibebuddyd`: the local daemon. It takes in events, connects to the box, reconnects, routes and keeps state.
- `beacon`: a command-line client that only talks to `vibebuddyd` and never opens the serial port itself (planned).
- `vibebuddy-fw`: the ESP32-S3 firmware. It only handles device I/O and VibeBuddy Protocol messages.
- VibeBuddy Protocol: an extensible NDJSON protocol, independent of the transport.

### Agents

Codex and Claude Code connect through local hooks. Both feed the same aggregator, and the task card's first line is the name the agent gave the session (the Claude app's conversation title, or Codex's thread name or branch), with the project name on the second line. Without a session name the project name goes first. The project name comes from the git root, so working in a subdirectory or worktree still shows the project.

The hook is a Rust binary in [`hook/`](hook/) (`vibebuddy-hook codex` / `vibebuddy-hook claude`). The app copies it to `~/Library/Application Support/VibeBuddy/bin/` and writes it into your user-level config, so it needs no Python and keeps working if you move the app (ADR-0005).

- Codex: six events in `~/.codex/hooks.json`. After they're written, review and trust them once on Codex's `/hooks` page. See [`docs/codex-adapter.md`](docs/codex-adapter.md).
- Claude Code: eight events in `~/.claude/settings.json`. See [`docs/claude-adapter.md`](docs/claude-adapter.md).
- OpenCode: a plugin of VibeBuddy's own at `~/.config/opencode/plugins/vibebuddy.js`, which hands each event to the hook.
- GitHub Copilot CLI: a hooks file of VibeBuddy's own at `~/.copilot/hooks/vibebuddy.json`. Copilot passes no reply at the end of a turn, so a question left at the end is announced as done.
- Pi (1.1.0 or later): an extension of VibeBuddy's own at `~/.pi/agent/extensions/vibebuddy.js`, which hands each event to the hook. A dialog an extension opens mid-run counts as waiting on you.

OpenCode's, Copilot's and Pi's files belong to VibeBuddy alone: connecting writes the whole file and removing deletes it, without touching your own config.

**Privacy:** the hook only forwards session and turn IDs, event names and the working directory. It never forwards prompts, assistant replies, transcripts or tool results. Both agents share the same rule for deciding whether the assistant is waiting for your answer.

### GitHub Actions

GitHub Actions doesn't use a hook: `vibebuddyd` polls `gh run list` every 30 seconds, using your existing GitHub login. **There's nothing to configure.** The repositories to watch are the projects an agent worked in during the last hour, and `owner/repo` is read from the `origin` remote in `.git/config`. See [`docs/ci.md`](docs/ci.md).

### Sending your own events

Anything that can make an HTTP request can put a card on the box:

```bash
curl -H 'content-type: application/json' \
  --data '{"version":1,"event":"task.done","title":"Hello"}' \
  http://127.0.0.1:7331/v1/events
```

See [`docs/protocol.md`](docs/protocol.md) for the events.

### Updates

The App and the box's firmware are released separately, and VibeBuddy looks for new versions of both ([ADR-0010](docs/adr/0010-firmware-and-app-release-separately-behind-an-update-manifest.md)). Apart from the Relay (next section), this is the only time it contacts anything on the internet:

- **When**: when it starts, once a day, and when you click Check now in Settings → General.
- **What it sends**: your platform (`macos-arm64`, `linux-x86_64` or `windows-x86_64`), the App's version and the box's firmware version. Nothing else: no ID, no hook data, nothing about your agents or projects. On the Mac, Sparkle also fetches the App's update feed, sending the usual User-Agent with the App's name and version; its system profiling stays off.
- **Where**: a signed list of releases at `https://updates.korekore.ai/vibebuddy/manifest.json` (and Sparkle's `appcast.xml` next to it), served by Cloudflare. The downloads themselves come from GitHub Releases.
- **What happens**: nothing is installed without you. A new App opens Sparkle's window on the Mac, where you can install, wait or skip; on Linux and Windows, General says how to upgrade. Newer firmware is downloaded and checked in the background, then Settings → Device offers it with a button.
- **Turning it off**: Settings → General → Check for updates. Builds from source have it off by default; the builds on the Releases page have it on.

### Wi-Fi and the Relay

Put the box on Wi-Fi (Settings → Device, with the box on the cable) and VibeBuddy reaches it without the cable: over the local network when this computer is on the same one, or through the VibeBuddy Relay when it isn't. The cable wins whenever it's plugged in, and moving between them doesn't drop the link ([ADR-0012](docs/adr/0012-the-relay-is-a-closed-cloudflare-service-with-pairing-not-accounts.md)). The box remembers up to 5 networks, say the office and home, and joins whichever it finds ([ADR-0023](docs/adr/0023-the-box-remembers-several-wi-fi-networks.md)); Settings → Device lists them and forgets each one.

- **Pairing**: the box and each computer have their own key. A computer pairs with the box when it's plugged in; nothing else can link to the box, over the network or the Relay.
- **What the Relay sees**: it runs on Cloudflare at `relay.korekore.ai`. While the box is on Wi-Fi it keeps a connection there, which carries its key, the names of the computers paired with it, and, while a computer is linked through the Relay, the lines that drive the box. Those lines (agent states, task titles, project names) are end-to-end encrypted between the computer and the box with the keys they exchanged when pairing, so the Relay can't read or change them; it sees which computer is linked to which box, when, and how much they send. The local network link is encrypted the same way. Firmware older than this links in the clear until it is updated over USB.
- **Turning it off**: Settings → General → Reach the box through the VibeBuddy Relay. With it off, this computer never contacts the Relay. The box still connects to it while it's on Wi-Fi; forget its networks to stop that.

### Giving the box to someone else

The box has its own key, which computers pair with when it's plugged in. Before the box changes hands, or if you think its key has leaked, give it a new one: hold K1 for the menu, then COMPUTERS → NEW ID, and confirm twice. The box makes a new key and forgets every paired computer, its Wi-Fi networks and its Relay, then restarts. Its Character, voice, volume and today's tally stay. Every computer then pairs again the next time it's plugged in, and the Wi-Fi networks are set again from the App. To forget the computers but keep the key, use FORGET ALL in the same place.

## Development

Everyday tasks live in the [`justfile`](justfile); run `just` to list them. See [`CONTRIBUTING.md`](CONTRIBUTING.md) for how to set up, test and send changes. The docs to start with are [`docs/architecture.md`](docs/architecture.md) (boundaries and decisions), [`CONTEXT.md`](CONTEXT.md) (domain terms), [`docs/pet.md`](docs/pet.md) (the buddy's design), [`docs/protocol.md`](docs/protocol.md) (protocol decisions), [`docs/references.md`](docs/references.md) (what we borrow from other projects, and where we stop) and [`LESSONS.md`](LESSONS.md) (lessons learned).

### Repository layout

```text
app/       # the macOS menu bar app (SwiftPM)
desktop/   # the Linux and Windows tray app and settings window (iced)
daemon/    # vibebuddyd
hook/      # vibebuddy-hook, the Codex and Claude Code hook
protocol/  # VibeBuddy Protocol types and codec
firmware-rs/  # vibebuddy-fw in Rust: core (no hardware) and device (hardware glue)
firmware/  # the previous C firmware (ESP-IDF), kept as a fallback
voices/    # announcement voices, one directory per voice
docs/      # architecture, protocol, hardware evidence, roadmap
tools/     # detection, flashing and asset scripts
```

### Firmware

The firmware is Rust (esp-hal + embassy, `no_std`) in two layers: [`firmware-rs/core`](firmware-rs/core) holds all the logic that doesn't touch hardware, and [`firmware-rs/device`](firmware-rs/device) is only hardware glue. The reasoning is in [ADR-0006](docs/adr/0006-firmware-in-rust-with-esp-hal.md), and the first on-device acceptance steps are in [`docs/firmware-bringup.md`](docs/firmware-bringup.md).

Install the Xtensa toolchain and espflash once (espflash builds the images), plus esptool, which writes them:

```bash
cargo install espup espflash --locked
pip install esptool
espup install --targets esp32s3
```

Connect the box's `USB-SLAVE` port, then:

```bash
just flash /dev/cu.usbmodem8401
uv run --with pyserial python tools/serial-hello.py /dev/cu.usbmodem8401
```

`just flash` builds the three images (bootloader, partition table, app) and writes them with a single esptool `write-flash`, together with a blank `otadata` so the box boots the app just written: one connection, one reset at the end. It leaves the `voices` partition and the settings area alone, so changing firmware keeps your voice.

Before flashing you can check the hardware-independent parts on the Mac: `just test-firmware` runs the firmware-core tests (state machine, drawing, serial protocol, storage, codec sequences) and compares the Rust and C firmware's screens pixel by pixel.

The firmware uses the custom partition table in [`firmware/partitions.csv`](firmware/partitions.csv) (a 4 MB app partition), because the voice assets no longer fit in the default 1 MB. espflash can't parse the custom subtype of the `voices` partition, so [`tools/make-partition-table.py`](tools/make-partition-table.py) compiles the table; the result matches ESP-IDF's `gen_esp32part.py` byte for byte.

The C firmware (`firmware/`, ESP-IDF) stays as a fallback until the Rust firmware finishes on-device acceptance: `just flash-c /dev/cu.usbmodem8401` flashes it back.

If the box is only connected through its `UART` port (the CH343 bridge, `/dev/cu.usbmodem5909…`), don't use `just flash`: with the default write block size it erases flash and then fails to write. Use [`tools/flash-bridge.sh`](tools/flash-bridge.sh), which flashes with `--no-stub` and 256-byte blocks, writing the partition table first as a test and then the app:

```bash
launchctl bootout gui/$(id -u)/com.vibebuddy.vibebuddyd
tools/build-firmware.sh
./tools/flash-bridge.sh /dev/cu.usbmodem59090668961 partition
./tools/flash-bridge.sh /dev/cu.usbmodem59090668961 app
launchctl bootstrap gui/$(id -u) ~/Library/LaunchAgents/com.vibebuddy.vibebuddyd.plist
```

`just flash` overwrites whatever firmware is on the box, including the factory `xiaozhi` firmware. Back it up first if you might want it back.

To find the box's serial port, run the probe once with the box unplugged and once plugged in:

```bash
./tools/detect-device.sh baseline
./tools/detect-device.sh connected
diff -ru .probe/baseline .probe/connected
```

The results can include your machine's USB device identifiers, so `.probe/` is ignored by Git.

### The app

The Mac app is a menu bar app. It carries `vibebuddyd` and `vibebuddy-hook` inside its bundle and supervises the daemon, replacing the old LaunchAgent. If it finds the old LaunchAgent, it offers to remove it and take over. Design: [`docs/app.md`](docs/app.md).

```bash
just install    # build the app, install it to /Applications and launch it
```

The app builds with SwiftPM and only needs the command-line tools. Packaging also collects third-party license notices with `cargo-about`; install the same version CI uses once, or the build stops at the license step:

```bash
cargo install cargo-about --version 0.9.2 --locked --features cli
```

`swift run --package-path app SelfTest` runs the view-model self-test.

### The daemon

Run `vibebuddyd` on its own:

```bash
cargo run -p vibebuddyd
```
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
## KiCad design hardware/rev-a/vibe-buddy-rev-a.kicad_pcb

File hardware/rev-a/README.md:

# Vibe Buddy Rev A 硬件工程

状态：九页原理图草稿（总页 + 八个电路子页），已有 `.kicad_pcb` 初步布局，尚未布线，不可下单。用 KiCad 打开 `vibe-buddy-rev-a.kicad_pro`，再双击 `vibe-buddy-rev-a.kicad_sch` 进入总图；`VB.kicad_sym` 是本工程的元件符号库。

## 当前实现与验证

- 主控、USB、电源、三个业务按键与复位、BOX3 裸屏接口、音频采集、音频电源和音频播放已建立元件与跨页连接，共 105 个实体元件、100 个网络。
- 主控暂选 ESP32-S3-WROOM-1-N16R8；音频采用 ES7210、ES8311、NS4150B，功放使用稳压 3V3，不能直接承受 USB VBUS 的全部允许电压范围。
- 2026-09-18，KiCad 10.0.6 ERC 检查为 **0 错误、0 警告**，报告见 `erc-draft.rpt`。这是默认规则下的连接检查，不代表供电设计、器件参数或生产审核通过。
- 九页均能导出 SVG/PDF，已检查主控、显示、音频播放页的渲染并修正标签遮挡和页框重叠；尚未完成全部页面逐项人工复核。
- 从 KiCad 导出的 XML 网表核对了九组关键网络：USB 重复触点、原生 USB D+/D-、LCD SPI、差分扬声器输出及复位。已运行 PCB DRC，尚有未连接、工艺及丝印问题，不能放行。
- `circuit.py` 和 `build_schematic.py` 是生成源；重新运行会覆盖本目录原理图。若在 KiCad 内修改，须先保留修改并同步生成源，不能直接重新生成。

## 本轮电源审核与 PCB 布局

- 新增 TPS22918 受控上电，选择具体电感及布局封装；电源预算发现普通500mA端口不足以保证Wi-Fi/声音/亮屏峰值同时运行，待完成供电管理。
- 已生成四层90×80mm工程布局，105个电路元件和4个安装孔，所有原理图脚号在PCB上有对应焊盘；0条走线。板形为工程审查占位，不是最终产品尺寸。
- 完整审核、封装依据和未解决项见 [电源与封装审核](power-footprint-review.md)。DRC报告见 `drc-layout.rpt`：当前4项USB定位孔间距错误、2项天线区丝印越界警告，以及264项未连接。没有忽略这些报错或导出生产包。
- `build_layout.py`读取KiCad导出的`layout-input.xml`生成PCB，重新运行会覆盖布局；手动编辑前应保留副本。可双击 `vibe-buddy-rev-a.kicad_pcb` 查看。

## 已确定范围

ESP32-S3 模组、Wi-Fi、2.4 英寸屏幕、单模拟麦克风、ES7210 采集、ES8311 播放、NS4150B 功放、单扬声器。对外仅一个 USB-C、三个业务按键和一个复位键，无 TF 卡及扩展插座。暂按 USB 供电、无电池设计；暂不接模型。

完整设计输入见 [PCB 设计输入](../../docs/pcb-rev-a.md)。既有 BOX 和面包板固件继续保留，不能直接以其引脚分配代替本板设计。

## 原理图分块

| 模块 | 连接与责任 | 完成前需核对 |
| --- | --- | --- |
| 电源与 USB | 单 USB-C 供电、原生 USB 数据、CC 电阻、保护、稳压和去耦 | USB 可用电流、总功耗、峰值负载、连接器封装与保护参数 |
| 主控 | ESP32-S3 模组、启动配置、复位、板内下载测试点 | 完整模组料号、焊盘、天线净空、启动和 USB 引脚 |
| 显示 | BOX 规格的 2.4 英寸显示屏及背光驱动 | 裸屏/模块选择、接口、连接器与引脚方向、背光电流 |
| 操作 | 三个业务键和独立复位键 | GPIO 分配、按键封装、机械位置和故障恢复流程 |
| 音频采集 | 模拟麦克风到 ES7210；ES8311 播放参考到另一采集通道 | 麦克风偏置、耦合、输入幅度、采样通道与时钟 |
| 音频播放 | ESP32-S3 到 ES8311，再到 NS4150B 和扬声器 | 功放电源、增益、控制脚、扬声器阻抗与功率 |

音频依据见 [官方 BOX3 原理图调查](../../docs/box-audio-research.md)。硬件参考输入不等于回声消除软件已经实现。

## 工程推进顺序

1. 配置 KiCad 及官方符号/封装库，确定工程版本。
2. 落实完整采购料号与原厂规格书；自建封装须逐项核对焊盘尺寸、编号和方向。
3. 绘制原理图并做电源预算、引脚审查与 ERC；未定项不得用猜测的封装填充。
4. 结合屏幕和外壳装配确定板框；暂以四层板为设计方向，进入布局布线后复核。
5. 完成 DRC、机械核对、人工电路复核和可制造性检查后导出生产包。
6. 少量样机验收通过后再考虑 20～50 台试卖。

PCB 设计与工厂文件检查均不能代替实机功能验证。

Notes on the sheet:
所有页面使用同名全局网络连接。已有未布线工程布局；机械配合与电源预算尚待验证，禁止投产。

Parts:
C30: 1u/10V; C_0603_1608Metric
C31: 10u/10V; C_0805_2012Metric
C32: 100n/16V; C_0603_1608Metric
R30, R31: 10k; R_0603_1608Metric
R32, R33: 4.7k; R_0603_1608Metric
R34, R35, R36: 33R; R_0603_1608Metric
TP1: BOOT0; TestPoint_Pad_D1.5mm
TP2: MCU_EN; TestPoint_Pad_D1.5mm
TP3: GND; TestPoint_Pad_D1.5mm
TP4: UART_TX; TestPoint_Pad_D1.5mm
TP5: UART_RX; TestPoint_Pad_D1.5mm
TP6: 3V3; TestPoint_Pad_D1.5mm
U1: ESP32-S3-WROOM-1-N16R8; ESP32-S3-WROOM-1; MPN ESP32-S3-WROOM-1-N16R8

Connections:
3V3: C31.1, C32.1, R30.1, R31.1, R32.1, R33.1, TP6.1, U1.2 (3V3); also elsewhere on the board
A_BCLK: R35.2; also elsewhere on the board
A_BCLK_SRC: R35.1, U1.7 (IO7)
A_DIN: U1.10 (IO17); also elsewhere on the board
A_DOUT: U1.9 (IO16); also elsewhere on the board
A_LRCK: R36.2; also elsewhere on the board
A_LRCK_SRC: R36.1, U1.8 (IO15)
A_MCLK: R34.2; also elsewhere on the board
A_MCLK_SRC: R34.1, U1.6 (IO6)
BOOT0: R31.2, TP1.1, U1.27 (IO0)
CC1_SENSE: U1.4 (IO4); also elsewhere on the board
CC2_SENSE: U1.5 (IO5); also elsewhere on the board
GND: C30.2, C31.2, C32.2, TP3.1, U1.1 (GND), U1.40 (GND), U1.41 (GND); also elsewhere on the board
I2C_SCL: R32.2, U1.38 (IO2); also elsewhere on the board
I2C_SDA: R33.2, U1.39 (IO1); also elsewhere on the board
KEY1_N: U1.23 (IO21); also elsewhere on the board
KEY2_N: U1.31 (IO38); also elsewhere on the board
KEY3_N: U1.32 (IO39); also elsewhere on the board
LCD_BL_N: U1.11 (IO18); also elsewhere on the board
LCD_CS_N: U1.18 (IO10); also elsewhere on the board
LCD_DC: U1.17 (IO9); also elsewhere on the board
LCD_MOSI: U1.19 (IO11); also elsewhere on the board
LCD_RESET_N: U1.12 (IO8); also elsewhere on the board
LCD_SCLK: U1.20 (IO12); also elsewhere on the board
MCU_EN: C30.1, R30.2, TP2.1, U1.3 (EN); also elsewhere on the board
PA_EN: U1.33 (IO40); also elsewhere on the board
UART_RX: TP5.1, U1.36 (RXD0)
UART_TX: TP4.1, U1.37 (TXD0)
USB_DM_MCU: U1.13 (USB_D-); also elsewhere on the board
USB_DP_MCU: U1.14 (USB_D+); also elsewhere on the board

Notes on the sheet:
ESP32-S3-WROOM-1-N16R8；GPIO 分配为本自研板专用。 BOOT0 测试点拉低后按复位进入恢复下载；无外露下载键。

Parts:
C10: 4.7u/10V; C_0603_1608Metric
C11, C12: 100n/16V; C_0603_1608Metric
J1: USB4105-GF-A; USB_C_Receptacle_GCT_USB4105-xx-A_16P_TopMnt_Horizontal; MPN USB4105-GF-A
R10, R11: 5.1k 1%; R_0603_1608Metric
R12, R13: 22R; R_0603_1608Metric
R14, R15, R16, R17: 100k 1%; R_0603_1608Metric
TP7: VBUS; TestPoint_Pad_D1.5mm
U2: USBLC6-2SC6; SOT-23-6; MPN USBLC6-2SC6

Connections:
CC1: J1.A5 (CC1), R10.1, R14.1
CC1_SENSE: C11.1, R14.2, R15.1; also elsewhere on the board
CC2: J1.B5 (CC2), R11.1, R16.1
CC2_SENSE: C12.1, R16.2, R17.1; also elsewhere on the board
GND: C10.2, C11.2, C12.2, J1.A1 (GND), J1.A12 (GND), J1.B1 (GND), J1.B12 (GND), J1.SH (SHIELD), R10.2, R11.2, R15.2, R17.2, U2.2 (GND); also elsewhere on the board
USB_DM: J1.A7 (D-), J1.B7 (D-), U2.1 (I/O1)
USB_DM_MCU: R12.2; also elsewhere on the board
USB_DM_PROT: R12.1, U2.6 (I/O1)
USB_DP: J1.A6 (D+), J1.B6 (D+), U2.3 (I/O2)
USB_DP_MCU: R13.2; also elsewhere on the board
USB_DP_PROT: R13.1, U2.4 (I/O2)
VBUS: C10.1, J1.A4 (VBUS), J1.A9 (VBUS), J1.B4 (VBUS), J1.B9 (VBUS), TP7.1, U2.5 (VBUS); also elsewhere on the board

Notes on the sheet:
USB-C 设备端；两路 CC 各自 5.1k 下拉。 输入浪涌、USB 枚举前功耗和限流策略仍属发布前待验证项。

Parts:
C13: 100n/16V; C_0603_1608Metric
C14, C18: 10u/10V; C_0805_2012Metric
C15, C16: 22u/10V; C_0805_2012Metric
C17: 1u/10V; C_0603_1608Metric
C19: 10n/16V; C_0603_1608Metric
L1: 4.7uH/4.6A; L_Bourns_SRP5030T; MPN SRP5030T-4R7M
U3: AP63203WU-7; TSOT-23-6; MPN AP63203WU-7
U4: AP2112K-3.3TRG1; SOT-23-5; MPN AP2112K-3.3TRG1
U8: TPS22918DBVR; SOT-23-6; MPN TPS22918DBVR

Connections:
3V3: C15.1, C16.1, L1.2, U3.1 (FB); also elsewhere on the board
A3V3: C18.1, U4.5 (VOUT); also elsewhere on the board
BUCK_BST: C13.1, U3.6 (BST)
BUCK_SW: C13.2, L1.1, U3.5 (SW)
GND: C14.2, C15.2, C16.2, C17.2, C18.2, C19.2, U3.4 (GND), U4.2 (GND), U8.2 (GND); also elsewhere on the board
SOFT_CT: C19.1, U8.4 (CT)
VBUS: U8.1 (VIN), U8.3 (ON); also elsewhere on the board
VBUS_SW: C14.1, C17.1, U3.2 (EN), U3.3 (IN), U4.1 (VIN), U4.3 (EN), U8.6 (VOUT)

Notes on the sheet:
3V3 开关稳压供主控、屏幕与功放；模拟电路使用独立 LDO。 2A 是稳压器能力，不代表 USB 主机允许取用 2A。

Notices in the files:
README.md:
License:
The source code is licensed under the [GNU General Public License v3.0 or later](LICENSE). That covers everything that draws the buddy, too, since its look and animations are defined in code.
The voice audio we hold the rights to, and any artwork added later, is licensed under [CC BY-SA 4.0](LICENSE-ASSETS). The two Chinese voices in `voices/` come from Volcano Engine's speech service and aren't covered; [`LICENSE-ASSETS`](LICENSE-ASSETS) lists exactly what is.
Neither license grants rights to the name "VibeBuddy" or the buddy character as a trademark.
