# Repository second-state/vibebuddy (continued)

## KiCad design hardware/rev-a/vibe-buddy-rev-a.kicad_pcb (continued)

Parts:
R1, R2, R3: 10k; R_0603_1608Metric
SW1: 业务键 1; SW_SPST_TL3305A; MPN TL3305AF160QG
SW2: 业务键 2; SW_SPST_TL3305A; MPN TL3305AF160QG
SW3: 业务键 3; SW_SPST_TL3305A; MPN TL3305AF160QG
SW4: 复位; SW_SPST_TL3305A; MPN TL3305AF160QG

Connections:
3V3: R1.1, R2.1, R3.1; also elsewhere on the board
GND: SW1.2, SW2.2, SW3.2, SW4.2; also elsewhere on the board
KEY1_N: R1.2, SW1.1; also elsewhere on the board
KEY2_N: R2.2, SW2.1; also elsewhere on the board
KEY3_N: R3.2, SW3.1; also elsewhere on the board
MCU_EN: SW4.1; also elsewhere on the board

Notes on the sheet:
业务键低电平有效，固件消抖。复位 EN 的 RC 网络位于主控页。 TL3305AF160QG 上按式工程候选；按帽高度与装配待验证。

Parts:
C40: 10u/10V; C_0805_2012Metric
C41: 100n/16V; C_0603_1608Metric
J2: TFT024B579-B0 接口（待核实）; Hirose_FH12-30S-0.5SH_1x30-1MP_P0.50mm_Horizontal; MPN FH12-30S-0.5SH(55)
Q1: MMBT3906; SOT-23; MPN MMBT3906
R40: 10R/0.125W; R_0603_1608Metric
R41: 4.7k; R_0603_1608Metric
R42: 1k; R_0603_1608Metric
R43: 10k; R_0603_1608Metric

Connections:
3V3: C40.1, C41.1, J2.4, J2.5, J2.6, J2.7, R40.1, R43.1; also elsewhere on the board
GND: C40.2, C41.2, J2.2, J2.3, J2.8, J2.13, J2.15, J2.16, J2.17, J2.18, J2.19, J2.20, J2.21, J2.22, J2.23, J2.24, J2.25, J2.26, J2.27, J2.28, J2.29, J2.30; also elsewhere on the board
LCD_BASE: Q1.1 (B), R41.2, R42.2
LCD_BL_N: R42.1, R43.2; also elsewhere on the board
LCD_CS_N: J2.10; also elsewhere on the board
LCD_DC: J2.12; also elsewhere on the board
LCD_EMITTER: Q1.2 (E), R40.2, R41.1
LCD_LEDA: J2.1, Q1.3 (C)
LCD_MOSI: J2.14; also elsewhere on the board
LCD_RESET_N: J2.9; also elsewhere on the board
LCD_SCLK: J2.11; also elsewhere on the board

Notes on the sheet:
参考 TFT024B579-B0：30P / 0.5mm / 下接 FPC，4 线 SPI。 不是 ATK-MD0240 的 29 针裸屏。屏幕采购、排线厚度和机械图仍需确认。 不使用触摸；背光电流按原厂屏幕规格复核后才能冻结。

Parts:
C50, C51, C52, C53, C54, C55, C56, C57, C58, C59, C61, C62, C63, C64: 1u/10V; C_0603_1608Metric
C60: 2.2u/10V; C_0603_1608Metric
MK1: CMC-4015-40P; MPN CMC-4015-40P
R60: 2.2k; R_0603_1608Metric
U5: ES7210; VQFN-32-1EP_4x4mm_P0.4mm_EP2.8x2.8mm; MPN ES7210

Connections:
ADC_A3V3: U5.22 (VDDA), U5.23 (VDDM); also elsewhere on the board
ADC_D3V3: U5.6 (VDDP), U5.7 (VDDD); also elsewhere on the board
A_BCLK: U5.9 (SCLK); also elsewhere on the board
A_DIN: U5.11 (SDOUT1); also elsewhere on the board
A_LRCK: U5.10 (LRCK); also elsewhere on the board
A_MCLK: U5.5 (MCLK); also elsewhere on the board
DAC_OUTN: C62.1; also elsewhere on the board
DAC_OUTP: C61.1; also elsewhere on the board
GND: C50.2, C51.2, C52.2, C53.2, C54.2, C55.2, C56.2, C57.2, C58.2, C59.2, C60.2, C64.1, MK1.2 (CASE/MIC-), U5.1 (AD0), U5.2 (AD1), U5.8 (GNDD), U5.21 (GNDA), U5.33 (EP); also elsewhere on the board
I2C_SCL: U5.4 (CCLK); also elsewhere on the board
I2C_SDA: U5.3 (CDATA); also elsewhere on the board
MIC1N: C64.2, U5.15 (MIC1N)
MIC1P: C63.2, U5.16 (MIC1P)
MIC2N: C53.1, U5.20 (MIC2N)
MIC2P: C52.1, U5.19 (MIC2P)
MIC4N: C56.1, U5.27 (MIC4N)
MIC4P: C57.1, U5.28 (MIC4P)
MICBIAS12: C60.1, R60.1, U5.24 (MICBIAS12)
MICBIAS34: C55.1, U5.26 (MICBIAS34)
MIC_SIGNAL: C63.1, MK1.1 (MIC+), R60.2
REFP12: C50.1, U5.17 (REFP12)
REFP34: C58.1, U5.29 (REFP34)
REFQ12: C51.1, U5.18 (REFQ12)
REFQ34: C59.1, U5.30 (REFQ34)
REFQM: C54.1, U5.25 (REFQM)
REF_INN: C62.2, U5.32 (MIC3N)
REF_INP: C61.2, U5.31 (MIC3P)

Notes on the sheet:
单模拟麦克风 + 功放前播放参考。原理图引脚按 ES7210 Rev22。 参考通道初始增益 0dB，避免与麦克风高增益混用；固件需配置双通道时序。

Parts:
C70, C73, C76, C79: 10u/10V; C_0805_2012Metric
C71, C72, C74, C75, C77, C78, C80: 100n/16V; C_0603_1608Metric
FB1, FB2, FB3, FB4: 120R@100MHz; L_0603_1608Metric; MPN BLM18PG121SN1D

Connections:
A3V3: FB1.1, FB2.1, FB3.1, FB4.1; also elsewhere on the board
ADC_A3V3: C73.1, C74.1, C75.1, FB2.2; also elsewhere on the board
ADC_D3V3: C70.1, C71.1, C72.1, FB1.2; also elsewhere on the board
DAC_A3V3: C79.1, C80.1, FB4.2; also elsewhere on the board
DAC_D3V3: C76.1, C77.1, C78.1, FB3.2; also elsewhere on the board
GND: C70.2, C71.2, C72.2, C73.2, C74.2, C75.2, C76.2, C77.2, C78.2, C79.2, C80.2; also elsewhere on the board

Notes on the sheet:
独立 A3V3 经磁珠分域；保持完整地平面，不将地切成孤岛。 每个音频电源脚就近 100nF；各域另有 10uF。封装与布局复核后发布。

Schematic: audio-playback.kicad_sch, 音频播放与功放

Parts:
C90, C91, C92, C93, C94: 2.2u/10V; C_0603_1608Metric
C95: 1u/10V; C_0603_1608Metric
C96: 10u/10V; C_0805_2012Metric
C97: 100n/16V; C_0603_1608Metric
FB5: 120R@100MHz; L_0603_1608Metric; MPN BLM18PG121SN1D
J3: 扬声器 4R/2W; JST_PH_B2B-PH-K_1x02_P2.00mm_Vertical; MPN B2B-PH-K-S
R61, R62: 30k; R_0603_1608Metric
R63: 100k; R_0603_1608Metric
U6: ES8311; VQFN-20-1EP_3x3mm_P0.4mm_EP1.7x1.7mm; MPN ES8311
U7: NS4150B; MSOP-8_3x3mm_P0.65mm; MPN NS4150B

Connections:
3V3: FB5.1; also elsewhere on the board
ADCVREF: C91.1, U6.15 (ADCVREF)
A_BCLK: U6.6 (SCLK); also elsewhere on the board
A_DOUT: U6.9 (DSDIN); also elsewhere on the board
A_LRCK: U6.8 (LRCK); also elsewhere on the board
A_MCLK: U6.2 (MCLK); also elsewhere on the board
DACVREF: C90.1, U6.14 (DACVREF)
DAC_A3V3: U6.11 (AVDD); also elsewhere on the board
DAC_D3V3: U6.3 (PVDD), U6.4 (DVDD); also elsewhere on the board
DAC_OUTN: C94.1, U6.13 (OUTN); also elsewhere on the board
DAC_OUTP: C93.1, U6.12 (OUTP); also elsewhere on the board
GND: C90.2, C91.2, C92.2, C95.2, C96.2, C97.2, R63.2, U6.5 (DGND), U6.10 (AGND), U6.20 (CE), U6.21 (EP), U7.7 (GND); also elsewhere on the board
I2C_SCL: U6.1 (CCLK); also elsewhere on the board
I2C_SDA: U6.19 (CDATA); also elsewhere on the board
PA_3V3: C96.1, C97.1, FB5.2, U7.6 (VCC)
PA_ACN: C94.2, R62.1
PA_ACP: C93.2, R61.1
PA_BYPASS: C95.1, U7.2 (BYPASS)
PA_EN: R63.1, U7.1 (CTRL); also elsewhere on the board
PA_INN: R62.2, U7.4 (INN)
PA_INP: R61.2, U7.3 (INP)
SPK_N: J3.2, U7.5 (VoN)
SPK_P: J3.1, U7.8 (VoP)
VMID: C92.1, U6.16 (VMID)

Notes on the sheet:
ES8311 输出分支：送 ES7210 采集播放参考，另经耦合电容和电阻到功放。 功放采用稳压 3V3，不直接连接 USB VBUS；PA_EN 下拉，默认关闭。 扬声器两端都是驱动输出，负端不能接地。
外接扬声器候选 CES-28266-24-L200；配线束/端子另确认。

Board: 4 copper layers, 109 parts (0 on the bottom side), 78 nets, no tracks yet.

Other parts of the board:
H1, H2, H3, H4: M2; MountingHole_2.2mm_M2
